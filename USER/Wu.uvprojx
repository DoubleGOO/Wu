# Keil uVision project Wu.uvprojx, settings and files
target Wu (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Wu +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F4XX
  c include: ..\FatFs;..\FWlib\inc;..\FWlib\Include;..\StartUp;..\USER;..\HARDWARE;..\HARDWARE\ADC;..\HARDWARE\AT45DB;..\HARDWARE\Camera;..\HARDWARE\GCS_Protocol;..\HARDWARE\GPS;..\HARDWARE\IMU;..\HARDWARE\LED;..\HARDWARE\LSM303D;..\HARDWARE\Math;..\HARDWARE\MPU6500;..\HARDWARE\MS5611;..\HARDWARE\PID;..\HARDWARE\PWM_Input;..\HARDWARE\PWM_Output;..\HARDWARE\Quadrotor;..\HARDWARE\Service;..\HARDWARE\UART1;..\HARDWARE\UART4;..\HARDWARE\Ultrasonic;..\HARDWARE\USART_DMA;..\CONFIG;..\HARDWARE\Flow
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c stm32f4xx_it.c
  group Lib
    ../FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dcmi.c
  group StartUp
    ../StartUp/: system_stm32f4xx.c startup_stm32f4xx.s
  group HardWareDriver
    ../HARDWARE/ADC/: STM32ADC.c
    ../HARDWARE/Camera/: Camera.c
    ../HARDWARE/AT45DB/: AT45DB.c
    ../HARDWARE/IMU/: IMU.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/GPS/: GPS.c
    ../HARDWARE/LSM303D/: LSM303D.c
    ../HARDWARE/MPU6500/: MPU6500.c
    ../HARDWARE/MS5611/: MS5611.c
    ../HARDWARE/PWM_Input/: PWM_Input.c
    ../HARDWARE/PWM_Output/: PWM_Output.c
    ../HARDWARE/Service/: delay.c IOI2C.c
    ../HARDWARE/UART1/: UART1.c
    ../HARDWARE/UART4/: UART4.c
    ../HARDWARE/Ultrasonic/: Ultrasonic.c
    ../HARDWARE/: SPI3.c
    ../HARDWARE/Flow/: flow.c
  group Quad
    ../HARDWARE/PID/: Pid.c
    ../HARDWARE/Quadrotor/: Quadrotor.c
    ../HARDWARE/GCS_Protocol/: GCS_Protocol.c
    ../HARDWARE/Math/: Fmath.c
  group Uart_DMA
    ../HARDWARE/USART_DMA/: OSQMem.c USART1DMATX.c
  group Fatfs
    ../FatFs/: diskio.c FAT_driver.c ff.c SD_init.c
